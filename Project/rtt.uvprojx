# Keil uVision project rtt.uvprojx, settings and files
target rtt (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: rtt_ +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\rtthread\3.0.3\bsp;..\rtthread\3.0.3\components\finish;..\rtthread\3.0.3\include;..\rtthread\3.0.3\include\libc;..\rtthread\3.0.3\src;..\rtthread\3.0.3\libcpu\arm\cortex-m3;..\User
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ../User/: main.c
  group rtt/ports
    ../rtthread/3.0.3/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group rtt/source
    ../rtthread/3.0.3/src/: thread.c scheduler.c object.c kservice.c idle.c clock.c irq.c
  group doc
    ../Doc/: readme.txt
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.1
